# Keil uVision project MS1793S-HID-shutter.uvprojx, settings and files
target APP-HID-shutter (ARM-ADS)
  device: MM32L051NT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MS1793S-HID-shutter +hex
  c flags: Optim=1
  c define: BLE_PAIR_SUPPORT
  c include: ..\MM32x031\HAL_lib\inc;..\MM32x031\Include;..\BSP;..\Src\inc;..\MM32x031\CMSIS\KEIL_CORE;..\Src\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../MM32x031/Source/: system_MM32x031.c
    ../MM32x031/Source/KEIL_StartAsm/: startup_MM32x031.s
  group BSP
    ./: BSP.c mm32f031_int.c
    ../BSP/: SPI.c
  group HALlib
    ../MM32x031/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group src
    ./: app_hogp.c main.c
    ../Src/lib/: mg_BLEPAIR_libv4_m0.lib
  group IWDG
    ../Src/IWDG/: iwdg.c
