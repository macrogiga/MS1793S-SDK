# Keil uVision project MS1793S-UartM.uvprojx, settings and files
target APP-UartM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L051NT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MS1793S-UartM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_UART SWDDEBUG CENTRAL
  c include: ..\MM32x031\HAL_lib\inc;..\MM32x031\Include;..\BSP;..\Src\inc;..\MM32x031\CMSIS\KEIL_CORE;..\Src\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../MM32x031/Source/: system_MM32x031.c
    ../MM32x031/Source/KEIL_StartAsm/: startup_MM32x031.s
  group BSP
    ./: BSP.c retarget.c mm32f031_int.c
    ../BSP/: UART.c SPI.c
  group HALlib
    ../MM32x031/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group src
    ./: app.c main.c
    ../Src/lib/: mg_BLE_libv4_m0.lib
  group IWDG
    ../Src/IWDG/: iwdg.c
target APP-UART-CMD (ARM-ADS)
  device: MM32L051NT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: as above
  output: MS1793S-AT-CMD +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_UART USE_AT_CMD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
